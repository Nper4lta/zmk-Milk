## config/boards/shields/two_buttons/Kconfig.defconfig
```kconfig
config ZMK_BLE
    default y

if SHIELD_TWO_BUTTONS

config ZMK_KEYBOARD_NAME
    default "BigButt" 

endif
```
